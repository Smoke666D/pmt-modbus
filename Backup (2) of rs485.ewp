# IAR project Backup (2) of rs485.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F103V8 ST STM32F103V8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; DEVICES\inc; DEVICES\src; LIB\; LIB\STM32F10x_StdPeriph_Driver\; LIB\STM32F10x_StdPeriph_Driver\inc; LIB\STM32F10x_StdPeriph_Driver\src; LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar\; LIB\Common\inc\; LIB\Common\src\; LIB\FlashEEPROM\inc\; LIB\FlashEEPROM\src\; LIB\ModBus\inc\; LIB\ModBus\src\; LIB\ADC\inc\; LIB\ADC\src\; LIB\SPI\inc\; LIB\SPI\src\; LIB\I2C\inc\; LIB\I2C\src\; LIB\STM32F10x_StdPeriph_Driver\; LIB\STM32F10x_StdPeriph_Driver\inc\; LIB\STM32F10x_StdPeriph_Driver\src\; LIB\HD44780\inc\; LIB\HD44780\src\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rs485.hex
  ILINK.IlinkOutputFile: rs485.out
  ILINK.IlinkIcfFile: rs485.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Common
    ./: main.c
  group Common/inc
    LIB/ADC/inc/: ADC.h
    LIB/FlashEEPROM/inc/: CRC.h FlashEEPROM.h
    LIB/: DIO.h PWM.h
    LIB/I2C/inc/: I2C.h
    ./: init.h
    LIB/SPI/inc/: SPI.h
    LIB/Common/inc/: system.h
  group Common/src
    LIB/ADC/src/: ADC.c
    LIB/FlashEEPROM/src/: CRC.c FlashEEPROM.c
    LIB/: DIO.c PWM.c
    LIB/I2C/src/: I2C.c
    ./: init.c
    LIB/SPI/src/: SPI.c
    LIB/Common/src/: system.c
  group DEVICES/inc
    DEVICES/inc/: BIC.h BIG.H BKC.h BKC01.h BKC14.h IT14.h KMG18.h TSP_SH.h
  group DEVICES/src
    DEVICES/src/: BIC.c BIG.C BKC.c BKC01.c BKC14.c IT14.c KMG18.C TSP_SH.c
  group lib
    LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group lib/inc
    LIB/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group lib/src
    LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MOD_BUS/inc
    LIB/ModBus/inc/: mb.h mbcrc.h mbfunc.h mbrtu.h port.h register.h USART.h user_process.h
  group MOD_BUS/src
    LIB/ModBus/src/: mb.c mbcrc.c mbfuncholding.c mbrtu.c register.c USART.c user_process.c
  group Periphery/inc
    LIB/HD44780/inc/: HD44780.h
  group Periphery/src
    LIB/HD44780/src/: HD44780.c
